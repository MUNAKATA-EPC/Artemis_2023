# Repository MUNAKATA-EPC/Artemis_2023

File README.md:

# 宗中アルテミス
2023シーズンの宗中アルテミスのデータをまとめたリポジトリです。詳細はWikiの方で。

このReadmeでは軽く自チームの紹介がてら結果報告やロボット概要をまとめておきます。
詳しくはいつか出る全国大会の記事で。

## 今年の結果
>  福岡ノード 優勝  
>  九州ブロック 優勝 / 優秀プレゼンテーション賞受賞  
>  ジャパンオープン 最終結果 18位 / 優秀プレゼンテーション賞受賞  
> その他オープン大会優勝 etc...  

## 全国機ロボット概要
* メインマイコン：Teensy 4.0
* サブマイコン：ATMega2560(ボールセンサ、ラインセンサ処理用)、Seeeduino Xiao(ジャイロセンサ処理用)
* モータードライバ：DSR-1202
* モーター：ジョンミンモーター x4
* IRセンサー：16個(円形)
* ラインセンサー：S4282-51 x25 + LED
* ジャイロセンサー：MPU6050(used dmp)
* カメラ：OpenMV H7
* 電源：Lipo 3cell(11.1V, 1300mAh)

## KiCad design KiCad_Projects/2023_early/Teensy_ver/mainboard/mainboard.kicad_pcb

Parts:
BZ1: Buzzer; Buzzer_12x9.5RM7.6
C1, C2: C; C_0402_1005Metric; LCSC C1555
C3, C5, C6, C7, C8, C20, C29: 100nF; C_0402_1005Metric; LCSC C41851
C4, C9, C10: 22pF; C_0402_1005Metric; LCSC C1555
C11: 1uF; C_0402_1005Metric; LCSC C167339
C12, C13, C14, C15, C16, C17, C18, C19, C21, C22, C23, C24, C25, C26, C27, C28: 104; C_0402_1005Metric; LCSC C1525
C30: C_Small; C_0603_1608Metric; LCSC C57112
C31, C35: C_Small; C_0603_1608Metric; LCSC C30926
C32, C33, C34, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C49: C_Small; C_0402_1005Metric; LCSC C1525
C36: C_Small; C_0603_1608Metric; LCSC C1604
D1, D2, D3, D4: LED; LED_0402_1005Metric; LCSC C130725
D5, D6, D7, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D22: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm; LCSC C2761795
D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D20, D21: D; D_A-405_P7.62mm_Horizontal
J1, J2: Conn_01x04_Female; PinSocket_1x04_P2.54mm_Vertical
J3, J5: Conn_01x06_Female; JST_XH_B6B-XH-A_1x06_P2.50mm_Vertical
J4: Conn_01x10_Female; PinHeader_1x10_P2.54mm_Vertical
J6: Conn_01x10_Female; PinSocket_1x10_P2.54mm_Vertical
J7: Conn_01x03_Female; PinSocket_1x03_P2.54mm_Vertical
J8: Conn_01x08_Female; PinSocket_1x08_P2.54mm_Vertical
J9: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J10: Conn_01x04_Female; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J11, J12: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
Q1, Q2: Q_NJFET_GDS; MSKSEMI
R1, R2, R3, R31, R32: 10k; R_0402_1005Metric; LCSC C25744
R4: 10K; R_0402_1005Metric; LCSC C25744
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20: 100K; R_0402_1005Metric; LCSC C25741
R21, R22, R23: 1k; R_0402_1005Metric; LCSC C105637
R24, R34: R_Trim; 可変抵抗(小)
R25, R27: R_Small; R_0603_1608Metric; LCSC C4190
R26: R_Small; R_0603_1608Metric; LCSC C23162
R28, R29: 100; R_0402_1005Metric; LCSC C25076
R30, R33, R35, R36: 1k; R_0402_1005Metric; LCSC C11702
SW1, SW2: SW_MEC_5G; SW_PUSH_6mm
SW3: SW_DIP_x01; 2MS1T2B4M2QES
SW4, SW5, SW6: SW_DIP_x01; SW_PUSH_6mm_H5mm
U1: ATmega2560-16AU; TQFP-100_14x14mm_P0.5mm
U2, U3, U4, U5, U6, U7, U8, U9, U11, U12, U13, U14, U15, U16, U17, U18: TSSP58038; TSSP58038_IR
U10: ATmega16U2-MU; QFN-32-1EP_5x5mm_P0.5mm_EP3.1x3.1mm
U19: open_mv; OpenMV
U20: MPU-6050; InvenSense_QFN-24_4x4mm_P0.5mm; LCSC C24112
U21: Teensy4.0; Teensy_Brakeout
Y1, Y2: Crystal; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C164049

Connections:
+3V3: C30.1, C31.2, D20.1 (K), J4.2, R25.2, R27.2, U20.8 (VDDIO), U20.13 (VDD)
+5V: C5.2, C6.2, C7.2, C8.2, C20.2, C32.2, C33.2, C34.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C49.2, D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D9.1 (VDD), D10.1 (VDD), D11.1 (VDD), D12.1 (VDD), D13.1 (VDD), D14.1 (VDD), D15.1 (VDD), D16.1 (VDD), D17.1 (VDD), D18.1 (VDD), D19.1 (VDD), D21.1 (K), D22.1 (VDD), J3.1, J5.1, J8.1, J10.1, J11.1, Q1.2 (D), Q2.2 (D), R1.1, R2.1, R3.2, R4.1, R24.1, R34.1, SW3.2, U1.10 (VCC), U1.31 (VCC), U1.61 (VCC), U1.80 (VCC), U1.100 (AVCC), U2.0 (Vin), U3.0 (Vin), U4.0 (Vin), U5.0 (Vin), U6.0 (Vin), U7.0 (Vin), U8.0 (Vin), U9.0 (Vin), U10.4 (VCC), U10.32 (AVCC), U11.0 (Vin), U12.0 (Vin), U13.0 (Vin), U14.0 (Vin), U15.0 (Vin), U16.0 (Vin), U17.0 (Vin), U18.0 (Vin), U19.2 (vin), U21.33 (VIN)
AREF: C3.1, U1.98 (AREF)
CS: J4.7, U21.12 (10_CS_MQSR)
Cam D+: J6.3, J7.2
Cam D-: J6.4, J7.3
Cam Data: U19.13 (txo/scl), U21.28 (21_A7_RX5_BCLK1)
FET 1 HIGH: J3.5, Q1.3 (S)
FET 1 LOW: J9.2, R28.2, U21.6 (4_BCLK2)
FET 2 HIGH: J3.6, Q2.3 (S)
FET 2 LOW: J9.3, R29.2, U21.7 (5_IN2)
GND: BZ1.2 (+), C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C30.2, C31.1, C32.1, C33.1, C34.1, C35.2, C36.2, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, D3.1 (K), D4.1 (K), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D9.3 (VSS), D10.3 (VSS), D11.3 (VSS), D12.3 (VSS), D13.3 (VSS), D14.3 (VSS), D15.3 (VSS), D16.3 (VSS), D17.3 (VSS), D18.3 (VSS), D19.3 (VSS), D22.3 (VSS), J3.2, J4.1, J5.2, J6.9, J6.10, J7.1, J8.2, J9.1, J10.2, J11.2, J12.2, R21.1, R26.2, R31.2, R32.2, SW1.3 (B), SW1.4 (B), SW2.3 (B), SW2.4 (B), SW4.2, SW5.2, SW6.2, U1.11 (GND), U1.32 (GND), U1.62 (GND), U1.81 (GND), U1.99 (GND), U2.1 (GND), U3.1 (GND), U4.1 (GND), U5.1 (GND), U6.1 (GND), U7.1 (GND), U8.1 (GND), U9.1 (GND), U10.3 (GND), U10.28 (UGND), U10.33 (GND), U11.1 (GND), U12.1 (GND), U13.1 (GND), U14.1 (GND), U15.1 (GND), U16.1 (GND), U17.1 (GND), U18.1 (GND), U19.1 (gnd), U20.1 (CLKIN), U20.11 (FSYNC), U20.18 (GND), U21.1 (GND), U21.32 (GND)
Gyro Data: U1.13 (PH1), U21.22 (15_A1_RX3_SPDIF_IN)
Gyro Reset: SW2.1 (A), SW2.2 (A), U1.78 (PA0)
IR1: C21.1, R13.1, U1.97 (PF0)
IR2: C22.1, R14.1, U1.96 (PF1)
IR3: C23.1, R15.1, U1.95 (PF2)
IR4: C24.1, R16.1, U1.94 (PF3)
IR5: C25.1, R17.1, U1.93 (PF4)
IR6: C26.1, R18.1, U1.92 (PF5)
IR7: C27.1, R19.1, U1.91 (PF6)
IR8: C28.1, R20.1, U1.90 (PF7)
IR9: C12.1, R5.1, U1.89 (PK0)
IR10: C13.1, R6.1, U1.88 (PK1)
IR11: C14.1, R7.1, U1.87 (PK2)
IR12: C15.1, R8.1, U1.86 (PK3)
IR13: C16.1, R9.1, U1.85 (PK4)
IR14: C17.1, R10.1, U1.84 (PK5)
IR15: C18.1, R11.1, U1.83 (PK6)
IR16: C19.1, R12.1, U1.82 (PK7)
IR D+: J6.7, U10.29 (D+)
IR D-: J6.8, U10.30 (D-)
IR Data: U1.46 (PD3), U21.9 (7_RX2_OUT1A)
L: J4.6, U21.44 (33_MCLK2)
Line D+: J5.6, J6.1
Line D-: J5.5, J6.2
Line Data: J5.4, U21.23 (16_A2_RX4_SCL1)
MD Data: J11.3, U21.3 (1_TX1_CTX2_MISO1)
MISO2: J1.2, U10.17 (PB3)
MOSI: J4.8, U21.13 (11_MOSI_CTX1)
MOSI2: J1.3, U10.16 (PB2)
Neo Pixel: D5.4 (DIN), U21.4 (2_OUT2)
unnamed: BZ1.1 (-), U21.5 (3_LRCLK2)
unnamed: C1.1, U1.34 (XTAL1), Y1.1
unnamed: C2.1, U1.33 (XTAL2), Y1.2
unnamed: C9.1, U10.1 (XTAL1), Y2.1
unnamed: C10.1, U10.2 (PC0/XTAL2), Y2.2
unnamed: C11.1, U10.27 (UCAP)
unnamed: C29.1, R21.2, U10.13 (~HWB/PD7)
unnamed: C35.1, U20.10 (REGOUT)
unnamed: C36.1, U20.20 (CPOUT)
unnamed: D1.2 (A), R30.1
unnamed: D2.2 (A), R33.1
unnamed: D3.2 (A), R35.1
unnamed: D4.2 (A), R36.1
unnamed: D5.2 (DOUT), D8.4 (DIN)
unnamed: D6.2 (DOUT), D9.4 (DIN)
unnamed: D10.2 (DOUT), D13.4 (DIN)
unnamed: D7.2 (DOUT), D10.4 (DIN)
unnamed: D11.2 (DOUT), D14.4 (DIN)
unnamed: D8.2 (DOUT), D11.4 (DIN)
unnamed: D12.2 (DOUT), D15.4 (DIN)
unnamed: D9.2 (DOUT), D12.4 (DIN)
unnamed: D13.2 (DOUT), D16.4 (DIN)
unnamed: D14.2 (DOUT), D17.4 (DIN)
unnamed: D15.2 (DOUT), D18.4 (DIN)
unnamed: D16.2 (DOUT), D19.4 (DIN)
unnamed: D6.4 (DIN), D17.2 (DOUT)
unnamed: D7.4 (DIN), D18.2 (DOUT)
unnamed: D19.2 (DOUT), D22.4 (DIN)
unnamed: D20.2 (A), J12.1
unnamed: D21.2 (A), J12.3
unnamed: J3.3, R24.2
unnamed: J5.3, R34.2
unnamed: Q1.1 (G), R28.1, R31.1
unnamed: Q2.1 (G), R29.1, R32.1
unnamed: R5.2, U2.2 (OUT)
unnamed: R6.2, U3.2 (OUT)
unnamed: R7.2, U4.2 (OUT)
unnamed: R8.2, U5.2 (OUT)
unnamed: R9.2, U6.2 (OUT)
unnamed: R10.2, U7.2 (OUT)
unnamed: R11.2, U8.2 (OUT)
unnamed: R12.2, U9.2 (OUT)
unnamed: R13.2, U11.2 (OUT)
unnamed: R14.2, U12.2 (OUT)
unnamed: R15.2, U13.2 (OUT)
unnamed: R16.2, U14.2 (OUT)
unnamed: R17.2, U15.2 (OUT)
unnamed: R18.2, U16.2 (OUT)
unnamed: R19.2, U17.2 (OUT)
unnamed: R20.2, U18.2 (OUT)
unnamed: R22.1, U10.8 (PD2)
unnamed: R23.1, U10.9 (PD3)
unnamed: R26.1, U20.9 (AD0)
unnamed: R30.2, R33.2, R35.2, SW3.1
unnamed: SW4.1, U19.8 (rst)
PB1: J2.4, U1.20 (PB1)
PB2: J2.3, U1.21 (PB2)
PB3: J2.2, U1.22 (PB3)
PB7: R36.2, U1.26 (PB7)
PRGB 1: SW5.1, U21.8 (6_OUT1D)
PRGB 2: SW6.1, U21.11 (9_OUT1C)
R: J4.5, U21.43 (32_OUT1B)
RESET: C4.1, C29.2, J2.1, R3.1, SW1.1 (A), SW1.2 (A), U1.30 (~RESET)
RESET2: J1.1, R4.2, U10.24 (PC1/~RESET)
RS: J4.9, U21.45 (34_DAT1_MISO2)
RX2LED: D1.1 (K), U10.11 (PD5)
RXD0: R23.2, U1.2 (PE0)
SCK: J4.10, U21.20 (13_SCK_CRX1_LED)
SCK2: J1.4, U10.15 (PB1)
SCL: J8.3, R1.2, R25.1, U1.43 (PD0), U20.23 (SCL)
SDA: J8.4, R2.2, R27.1, U1.44 (PD1), U20.24 (SDA)
Start: J4.3, U21.41 (30_CRX3)
Stop: J4.4, U21.42 (31_CTX3)
TX2LED: D2.1 (K), U10.10 (PD4)
TXD0: R22.2, U1.3 (PE1)
Teensy D+: J6.6, U21.54 (D+)
Teensy D-: J6.5, U21.53 (D-)
Touch: J3.4, U21.14 (12_MISO_MQSL)
XBee RX: J10.4, U21.36 (25_A11_RX6_SDA2)
XBee TX: J10.3, U21.35 (24_A10_TX6_SCL2)

Board: 2 copper layers, 120.0 x 120.0 mm, 151 parts (34 on the bottom side), 122 nets.

## KiCad design KiCad_Projects/その他/ジャイロ/ジャイロ.kicad_pcb

Parts:
J1: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: R_Potentiometer_Trim_US; TA48033S
SW1: SW_Push; SW_PUSH_6mm_H7.3mm
U1: SeeeduinoXIAO; seeeduinoXIAO
U3: L3GD20H_Module

Connections:
+3V3: R1.2, R2.2, RV1.2, SW1.1, U1.12 (3V3), U3.1 (VCC), U3.8 (CS)
+5V: J1.1, U1.14 (5V)
A1: RV1.3, U1.3 (PA10_A2_D2)
A2: SW1.2, U1.2 (PA4_A1_D1)
GND: J1.3, RV1.1, U1.13 (GND), U3.4 (SA0), U3.5 (GND), U3.6 (INT1), U3.7 (INT2)
RX: J1.4, U1.8 (PB09_A7_D7_RX)
SCL: R1.1, U1.6 (PA9_A5_D5_SCL), U3.2 (SCL)
SDA: R2.1, U1.5 (PA8_A4_D4_SDA), U3.3 (SDA)
TX: J1.2, U1.7 (PB08_A6_D6_TX)

Board: 2 copper layers, 33.2 x 40.0 mm, 7 parts (0 on the bottom side), 9 nets.

## KiCad design KiCad_Projects/2023_early/Teensy_ver/line_sensor/line_Inergrate/ライン統合-2023-05-24_220913/Untitled.kicad_pcb

Parts:
J1, J2, J3: Conn_01x05_Socket; PinHeader_1x05_P2.54mm_Vertical
J4, J5: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical
J6, J7, J8, J9, J10, J11: Conn_01x01_Socket; PinHeader_1x01_P2.54mm_Vertical

Connections:
5V: J1.4, J2.4, J3.4, J4.3, J5.3, J10.1, J11.1
GND: J1.3, J2.3, J3.3, J4.2, J5.2
LED: J1.5, J2.5, J3.5, J4.1, J5.1, J6.1, J7.1, J8.1, J9.1
信号線: J1.1, J1.2, J2.1, J2.2, J3.1, J3.2, J4.4, J5.4

Board: 2 copper layers, 68.0 x 68.0 mm, 11 parts (0 on the bottom side), 4 nets.

## KiCad design KiCad_Projects/2023_early/Teensy_ver/kikker_board/kikker_board.kicad_pcb

Parts:
C1: C_Small; C_0402_1005Metric
J1, J3, J5: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J2: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4, J6: Conn_01x04_Female; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
Q1: Q_NMOS_GDS; FS70SMJ
R1: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3: 1; 5W 1Ω sement

Connections:
+5V: C1.2, J4.2, J6.2
Brightness: J5.1, J6.3
FET 1: J1.1, R1.1
FET 2: J1.2, J2.3
GND: C1.1, J4.3, J6.1
Kathode: J4.4, J5.2
unnamed: J2.1, Q1.3 (S), R2.2
unnamed: J2.2, J3.1
unnamed: J3.2, R3.1
unnamed: Q1.1 (G), R1.2, R2.1
unnamed: Q1.2 (D), R3.2
Vout: J4.1, J6.4

Notes on the sheet:
LED
メインへ
フォトIC

Board: 2 copper layers, 87.3 x 30.0 mm, 11 parts (0 on the bottom side), 12 nets.

## KiCad design KiCad_Projects/2023_early/Teensy_ver/IO_Board_Teensy/IO_Board.kicad_pcb

Board: 2 copper layers, 85.4 x 76.0 mm, 36 parts (0 on the bottom side), 43 nets.

Parts:
C3, C4, C5, C6, C7, C8, C10, C11, C12: C_Small; C_0402_1005Metric
FB1, FB2: Ferrite_Bead; Fuse_0805_2012Metric
J1, J2, J4, J7: USB_C_Receptacle_USB2.0; USB_C_Receptacle_XKB_U262-16XN-4BVC11
J3, J5: Conn_01x10_Female; PinHeader_1x10_P2.54mm_Vertical
J6: Conn_01x17_Female; LCDmodule_aqm1248a
L: SW_DIP_x01; SW_PUSH_6mm_H5mm
R: SW_DIP_x01; SW_PUSH_6mm_H5mm
R1, R4: 10K; R_0402_1005Metric
R2, R3, R6, R7, R8, R9, R12, R13: R; R_0402_1005Metric
R5, R10, R11, R14: 22R; R_0402_1005Metric
START: SW_DIP_x01; SW_PUSH_6mm_H5mm
STOP: SW_DIP_x01; SW_PUSH_6mm_H5mm

Connections:
+3V3: C4.2, J3.2, J6.6, R1.1, R4.2
CS: J3.7, J6.1, R4.1
Cam D+: J4.A6 (D+), J4.B6 (D+), J5.3
Cam D-: J4.A7 (D-), J4.B7 (D-), J5.4
GND: C3.1, C4.1, C7.1, C8.1, C10.1, C11.1, C12.1, FB1.1, FB2.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J3.1, J4.A1 (GND), J4.A12 (GND), J4.B1 (GND), J4.B12 (GND), J4.S1 (SHIELD), J5.9, J5.10, J6.7, J7.A1 (GND), J7.A12 (GND), J7.B1 (GND), J7.B12 (GND), L.1, R.1, R2.2, R3.2, R6.2, R7.2, R8.1, R9.1, R12.1, R13.1, START.1, STOP.1
IR D+: J5.7, R5.1
IR D-: J5.8, R10.1
L: J3.6, L.2
Line D+: J5.1, R11.1
Line D-: J5.2, R14.1
MOSI: J3.8, J6.5
unnamed: C3.2, J6.8
unnamed: C5.1, J6.9
unnamed: C5.2, J6.10
unnamed: C6.1, J6.11
unnamed: C6.2, J6.12
unnamed: C7.2, J6.13
unnamed: C8.2, J6.14
unnamed: C10.2, J6.15
unnamed: C11.2, J6.16
unnamed: C12.2, J6.17
unnamed: FB1.2, J2.S1 (SHIELD)
unnamed: FB2.2, J7.S1 (SHIELD)
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R3.1
unnamed: J2.A5 (CC1), R8.2
unnamed: J2.A6 (D+), J2.B6 (D+), R5.2
unnamed: J2.A7 (D-), J2.B7 (D-), R10.2
unnamed: J2.B5 (CC2), R9.2
unnamed: J4.A5 (CC1), R6.1
unnamed: J4.B5 (CC2), R7.1
unnamed: J6.2, R1.2
unnamed: J7.A5 (CC1), R12.2
unnamed: J7.A6 (D+), J7.B6 (D+), R11.2
unnamed: J7.A7 (D-), J7.B7 (D-), R14.2
unnamed: J7.B5 (CC2), R13.2
R: J3.5, R.2
RS: J3.9, J6.3
SCK: J3.10, J6.4
Start: J3.3, START.2
Stop: J3.4, STOP.2
Teensy D+: J1.A6 (D+), J1.B6 (D+), J5.6
Teensy D-: J1.A7 (D-), J1.B7 (D-), J5.5

## KiCad design KiCad_Projects/2023_early/Teensy_ver/Kiker_PSU/Kiker_PSU.kicad_pcb

Board: 2 copper layers, 56.9 x 61.5 mm, 9 parts (0 on the bottom side), 9 nets.

Parts:
C1: 4700; C_Radial_D16.0mm_H31.5mm_P7.50mm
D1: D; D_DO-15_P10.16mm_Horizontal
Kiker: Conn_01x03_Female; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
PSU: Conn_01x02_Female; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
Q1: Q_NMOS_GDS; K15A20D
R1: 10K; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R2: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3: 1; 5W 1Ω sement
U1: XL6009

Connections:
+12V: D1.1 (K), U1.1 (IN+)
GND: PSU.1, U1.2 (IN-)
unnamed: C1.1, Kiker.2, U1.3 (OUT+)
unnamed: C1.2, Kiker.3, R3.1
unnamed: D1.2 (A), PSU.2
unnamed: Kiker.1, R2.1
unnamed: Q1.1 (G), R1.2, R2.2
unnamed: Q1.2 (D), R3.2
unnamed: Q1.3 (S), R1.1, U1.4 (OUT-)
